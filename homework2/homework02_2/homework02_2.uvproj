# Keil uVision project homework02_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: homework02_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: homework02_2.c
